Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: Tekla.ifc
Time: 2022-11-29T15:34:28
Author: RV-PC\W77
Organization: Structural Designer
Written by: IFC Database version:Work
Made in: Tekla Structures 21.1, IFC Export Version: 4.0.0.0 Sep 11 2015

# IfcSite, Undefined
RefElevation: 0 mm

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: PL2*400 (120)
In: Undefined
Description: PL2*400; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: CO0(?); Repère d'assemblage: CO0(?); Classe: 99; Matériau: S235JR; Profil: PL2*400; Nom: CORNIERE
Tekla Quantités - Poids: 0.6 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 130.4 m2; Surface nette: 0.1 m2; Hauteur: 400 mm; Largeur: 2 mm; Longueur: 106 mm
Pset_BeamCommon - LoadBearing: yes; Reference: CO0(?)
BaseQuantities - Length: 106 mm; OuterSurfaceArea: 0.088432 m2; NetVolume: 0.0000864 m3; NetWeight: 0.67824 kg
Name | Niveau bas | Niveau haut | Phase
4 x CORNIERE | +0.754 | +0.804 | 268
4 x CORNIERE | +1.404 | +1.454 | 268
4 x CORNIERE | +2.941 | +3.344 | 268
4 x CORNIERE | +3.284 | +3.687 | 268
4 x CORNIERE | +0.179 | +0.229 | 268
4 x CORNIERE | +2.054 | +2.104 | 268
16 x CORNIERE | +0.754 | +0.804 | 1
16 x CORNIERE | +1.404 | +1.454 | 1
16 x CORNIERE | +2.054 | +2.104 | 1
16 x CORNIERE | +2.941 | +3.344 | 267
16 x CORNIERE | +3.284 | +3.687 | 267
16 x CORNIERE | +0.179 | +0.229 | 1

# IfcBeam: PL4*105 (10)
In: Undefined
Description: PL4*105; Material: STEEL/S235JR
Pset_BeamCommon - LoadBearing: yes; Reference: AT0(?)
Tekla Commun - Repère de pièce: AT0(?); Repère d'assemblage: AT0(?); Classe: 3; Matériau: S235JR; Profil: PL4*105; Nom: ATTACHE
Tekla Quantités - Poids: 1 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 66.9 m2; Surface nette: 0.1 m2; Hauteur: 105 mm; Largeur: 4 mm; Longueur: 290 mm
BaseQuantities - Length: 289.983 mm; OuterSurfaceArea: 0.0649283 m2; NetVolume: 0.000123473 m3; NetWeight: 0.969263 kg
Name | Niveau bas | Niveau haut | Phase
2 x ATTACHE | +2.838 | +2.949 | 268
4 x ATTACHE | +3.883 | +3.993 | 267
4 x ATTACHE | +2.838 | +2.949 | 267

# IfcBeam: PL4*150 (16)
In: Undefined
Description: PL4*150; Material: STEEL/Steel_Undefined
Pset_BeamCommon - LoadBearing: yes; Reference: A0(?)
Tekla Commun - Repère de pièce: A0(?); Repère d'assemblage: A0(?); Matériau: Steel_Undefined; Profil: PL4*150; Nom: AT CROIX
Tekla Quantités - Poids: 2.9 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 65.8 m2; Surface nette: 0.2 m2; Hauteur: 150 mm; Largeur: 4 mm; Longueur: 602 mm
BaseQuantities - Length: 602 mm; OuterSurfaceArea: 0.18908 m2; NetVolume: 0.000366 m3; NetWeight: 2.8731 kg
Name | Niveau bas | Niveau haut | Phase | Classe
4 x AT CROIX | +3.598 | +3.828 | 264 | 6
4 x AT CROIX | +2.595 | +2.826 | 264 | 6
4 x AT CROIX | +0.344 | +0.494 | 265 | 99
4 x AT CROIX | +2.404 | +2.554 | 265 | 99

# IfcBeam: PL4*180 (12)
In: Undefined
Description: PL4*180; Material: STEEL/S235JR
Tekla Commun - Classe: 99; Matériau: S235JR; Profil: PL4*180
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 180 mm; Largeur: 4 mm
Pset_BeamCommon - LoadBearing: yes
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Phase | Nom | Poids (kg) | Surface par tonne (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x ATTACHE | +2.808 | +2.993 | AT0(?) | 267 | ATTACHE | 1.1 | 66.4 | 190 | 190.013 | 0.0728369 | 0.00013969 | 1.09656
4 x ATTACHE | +3.146 | +3.249 | AT0(?) | 258 | ATTACHE | 0.8 | 66.9 | 131.6 | 131.569 | 0.05112 | 0.0000972 | 0.76302
4 x PLATINE | +0.000 | +0.102 | PL0(?) | 258 | PLATINE | 1 | 66.7 | 166 | 166 | 0.064 | 0.0001224 | 0.96084

# IfcBeam: PL4*200 (91)
In: Undefined
Description: PL4*200; Material: STEEL/S235JR
Tekla Commun - Classe: 99; Matériau: S235JR; Profil: PL4*200
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 200 mm; Largeur: 4 mm
Pset_BeamCommon - LoadBearing: yes
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Phase | Nom | Poids (kg) | Surface par tonne (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x PLATINE | +2.683 | +2.725 | PL0(?) | 252 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
10 x PLATINE | +0.187 | +0.229 | PL0(?) | 252 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
10 x PLATINE | +2.063 | +2.105 | PL0(?) | 252 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
4 x ATTACHE | +3.842 | +4.047 | AT0(?) | 268 | ATTACHE | 1.2 | 66.3 | 0.1 | 190 | 190.013 | 0.0807574 | 0.000155211 | 1.2184
4 x ATTACHE | +2.609 | +2.656 | AT0(?) | 268 | ATTACHE | 1.2 | 66.3 | 0.1 | 205 | 205.003 | 0.0868733 | 0.000167203 | 1.31254
2 x ATTACHE | +2.798 | +3.003 | AT0(?) | 268 | ATTACHE | 1.2 | 66.3 | 0.1 | 190 | 189.993 | 0.0807492 | 0.000155195 | 1.21828
2 x ATTACHE | +2.798 | +3.003 | AT0(?) | 268 | ATTACHE | 1.2 | 66.3 | 0.1 | 190 | 190.013 | 0.0807574 | 0.000155211 | 1.2184
8 x ATTACHE | +2.798 | +3.003 | AT0(?) | 267 | ATTACHE | 1.2 | 66.3 | 0.1 | 190 | 190.013 | 0.0807574 | 0.000155211 | 1.2184
16 x ATTACHE | +3.842 | +4.047 | AT0(?) | 267 | ATTACHE | 1.2 | 66.3 | 0.1 | 190 | 190.013 | 0.0807574 | 0.000155211 | 1.2184
12 x ATTACHE | +2.609 | +2.656 | AT0(?) | 65 | ATTACHE | 1.2 | 66.3 | 0.1 | 205 | 205.003 | 0.0868733 | 0.000167203 | 1.31254
4 x ATTACHE | +2.798 | +3.003 | AT0(?) | 267 | ATTACHE | 1.2 | 66.3 | 0.1 | 190 | 189.993 | 0.0807492 | 0.000155195 | 1.21828
4 x PLATINE | +1.154 | +1.206 | PL0(?) | 252 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
4 x PLATINE | +2.053 | +2.105 | PL0(?) | 252 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
4 x PLATINE | +1.012 | +1.054 | PL0(?) | 252 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
2 x PLATINE | +2.063 | +2.105 | PL0(?) | 262 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
2 x PLATINE | +0.000 | +0.102 | PL0(?) | 252 | PLATINE | 0.8 | 66.7 | 0.1 | 146 | 146 | 0.0628 | 0.00012 | 0.942
ATTACHE | +12.793 | +12.998 | AT0(?) | 59 | ATTACHE | 1.2 | 66.3 | 0.1 | 190 | 190.013 | 0.0807574 | 0.000155211 | 1.2184

# IfcBeam: PL4*250 (26)
In: Undefined
Description: PL4*250; Material: STEEL/S235JR
Pset_BeamCommon - LoadBearing: yes; Reference: CO0(?)
Tekla Commun - Niveau bas: +0.000; Niveau haut: +0.054; Repère de pièce: CO0(?); Repère d'assemblage: CO0(?); Classe: 99; Matériau: S235JR; Profil: PL4*250; Nom: CORNIERE
Tekla Quantités - Poids: 0.8 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 67.2 m2; Surface nette: 0.1 m2; Hauteur: 250 mm; Largeur: 4 mm; Longueur: 100 mm
BaseQuantities - Length: 100 mm; OuterSurfaceArea: 0.054832 m2; NetVolume: 0.000104 m3; NetWeight: 0.8164 kg
Name | Phase
24 x CORNIERE | 262
2 x CORNIERE | 65

# IfcBeam: PL4*300 (4)
In: Undefined
Description: PL4*300; Material: STEEL/Steel_Undefined
Pset_BeamCommon - LoadBearing: yes; Reference: A0(?)
Tekla Commun - Niveau bas: +3.088; Niveau haut: +3.341; Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 264; Classe: 6; Matériau: Steel_Undefined; Profil: PL4*300; Nom: AT CROIX
Tekla Quantités - Poids: 5.7 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 65 m2; Surface nette: 0.4 m2; Hauteur: 300 mm; Largeur: 4 mm; Longueur: 602 mm
BaseQuantities - Length: 602 mm; OuterSurfaceArea: 0.37328 m2; NetVolume: 0.000732 m3; NetWeight: 5.7462 kg

# IfcBeam: SADEF-C+200X1.50 (87)
In: Undefined
Description: SADEF-C+200X1.50
Tekla Commun - Profil: SADEF-C+200X1.50
Tekla Quantités - Volume: 0 m3; Surface par tonne: 151.5 m2; Hauteur: 200 mm; Largeur: 100 mm
Pset_BeamCommon - LoadBearing: yes
Name | Material | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Phase | Classe | Matériau | Nom | Poids (kg) | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x ARBA | STEEL/Steel_Undefined | +3.117 | +3.568 | A0(?) | 1 | 6 | Steel_Undefined | ARBA | 15.8 | 0 | 2.8 | 2775.2 | 2775.17 | 2.38664 | 0.00209803 | 16.4695
2 x ARBA | STEEL/Steel_Undefined | +3.372 | +3.823 | A0(?) | 1 | 6 | Steel_Undefined | ARBA | 15.8 | 0 | 2.8 | 2775.2 | 2775.17 | 2.38664 | 0.00209803 | 16.4695
2 x ARBA | STEEL/Steel_Undefined | +3.116 | +3.823 | A0(?) | 1 | 6 | Steel_Undefined | ARBA | 32.5 | 0 | 5.8 | 5729.3 | 5729.25 | 4.92716 | 0.00433131 | 34.0008
2 x ARBA | STEEL/Steel_Undefined | +2.857 | +3.309 | A0(?) | 1 | 6 | Steel_Undefined | ARBA | 15.8 | 0 | 2.8 | 2775.2 | 2775.17 | 2.38664 | 0.00209803 | 16.4695
2 x ARBA | STEEL/Steel_Undefined | +2.602 | +3.054 | A0(?) | 1 | 6 | Steel_Undefined | ARBA | 15.8 | 0 | 2.8 | 2775.2 | 2775.17 | 2.38664 | 0.00209803 | 16.4695
2 x ARBA | STEEL/Steel_Undefined | +2.602 | +3.311 | A0(?) | 1 | 6 | Steel_Undefined | ARBA | 32.5 | 0 | 5.8 | 5729.3 | 5729.25 | 4.92716 | 0.00433131 | 34.0008
LISSE | STEEL/S235JR | +2.725 | +2.825 | LS0(?) | 262 | 14 | S235JR | LISSE | 28.6 | 0.4 | 5.2 | 5042 | 5042.03 | 4.33615 | 0.00381177 | 29.9224
LISSE | STEEL/S235JR | +0.229 | +0.329 | LS0(?) | 262 | 14 | S235JR | LISSE | 28.6 | 0.4 | 5.2 | 5042 | 5042.03 | 4.33615 | 0.00381177 | 29.9224
LISSE | STEEL/S235JR | +2.105 | +2.205 | LS0(?) | 262 | 14 | S235JR | LISSE | 28.6 | 0.4 | 5.2 | 5042 | 5042.03 | 4.33615 | 0.00381177 | 29.9224
2 x LISSE | STEEL/S235JR | +0.229 | +0.329 | LS0(?) | 262 | 14 | S235JR | LISSE | 21.9 | 0.4 | 3.9 | 3860.2 | 3860.16 | 3.31974 | 0.00291828 | 22.9085
4 x LISSE | STEEL/S235JR | +2.105 | +2.205 | LS0(?) | 262 | 14 | S235JR | LISSE | 21.9 | 0.4 | 3.9 | 3860.2 | 3860.16 | 3.31974 | 0.00291828 | 22.9085
2 x PANNE | STEEL/S235JR | +3.123 | +3.336 | PA0(?) | 268 | 5 | S235JR | PANNE | 28.3 | 0 | 5 | 4982 | 4982 | 4.28452 | 0.00376639 | 29.5662
2 x PANNE | STEEL/S235JR | +2.783 | +2.996 | PA0(?) | 268 | 5 | S235JR | PANNE | 28.3 | 0 | 5 | 4982 | 4982 | 4.28452 | 0.00376639 | 29.5662
2 x PANNE | STEEL/S235JR | +3.827 | +4.040 | PA0(?) | 268 | 5 | S235JR | PANNE | 28.3 | 0 | 5 | 4982 | 4982 | 4.28452 | 0.00376639 | 29.5662
2 x PANNE | STEEL/S235JR | +3.466 | +3.679 | PA0(?) | 268 | 5 | S235JR | PANNE | 28.3 | 0 | 5 | 4982 | 4982 | 4.28452 | 0.00376639 | 29.5662
2 x LISSE | STEEL/S235JR | +0.229 | +0.329 | LS0(?) | 268 | 14 | S235JR | LISSE | 28.3 | 0.4 | 5 | 4982 | 4982 | 4.28452 | 0.00376639 | 29.5662
2 x LISSE | STEEL/S235JR | +2.656 | +2.756 | LS0(?) | 268 | 14 | S235JR | LISSE | 28.3 | 0.4 | 5 | 4982 | 4982 | 4.28452 | 0.00376639 | 29.5662
4 x LISSE | STEEL/S235JR | +3.123 | +3.336 | LS0(?) | 267 | 14 | S235JR | LISSE | 27.1 | 0 | 4.8 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
4 x LISSE | STEEL/S235JR | +2.783 | +2.996 | LS0(?) | 267 | 14 | S235JR | LISSE | 27.1 | 0 | 4.8 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
4 x LISSE | STEEL/S235JR | +3.827 | +4.040 | LS0(?) | 267 | 14 | S235JR | LISSE | 27.1 | 0 | 4.8 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
4 x LISSE | STEEL/S235JR | +3.466 | +3.679 | LS0(?) | 267 | 14 | S235JR | LISSE | 27.1 | 0 | 4.8 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
4 x LISSE | STEEL/S235JR | +2.656 | +2.756 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.1 | 0.4 | 4.8 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
4 x LISSE | STEEL/S235JR | +0.229 | +0.329 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.1 | 0.4 | 4.8 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
4 x PANNE | STEEL/S235JR | +3.123 | +3.336 | PA0(?) | 267 | 5 | S235JR | PANNE | 27.7 | 0 | 4.8 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
4 x PANNE | STEEL/S235JR | +2.783 | +2.996 | PA0(?) | 267 | 5 | S235JR | PANNE | 27.7 | 0 | 4.8 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
4 x PANNE | STEEL/S235JR | +3.827 | +4.040 | PA0(?) | 267 | 5 | S235JR | PANNE | 27.7 | 0 | 4.8 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
4 x PANNE | STEEL/S235JR | +3.466 | +3.679 | PA0(?) | 267 | 5 | S235JR | PANNE | 27.7 | 0 | 4.8 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
4 x LISSE | STEEL/S235JR | +0.229 | +0.329 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.7 | 0.4 | 4.8 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
4 x LISSE | STEEL/S235JR | +2.656 | +2.756 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.7 | 0.4 | 4.8 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
2 x LISSE | STEEL/S235JR | +1.054 | +1.154 | LS0(?) | 262 | 14 | S235JR | LISSE | 16.2 | 0.6 | 2.9 | 2862.7 | 2862.72 | 2.46194 | 0.00216422 | 16.9891
2 x LISSE | STEEL/S235JR | +0.229 | +0.329 | LS0(?) | 262 | 14 | S235JR | LISSE | 16.2 | 0.2 | 2.9 | 2862.7 | 2862.72 | 2.46194 | 0.00216422 | 16.9891
2 x LISSE | STEEL/S235JR | +1.159 | +2.100 | LS0(?) | 252 | 14 | S235JR | LISSE | 5.3 | 0 | 1 | 941 | 941 | 0.80926 | 0.000711396 | 5.58446

# IfcBeam: SADEF-C+200X2.00 (41)
In: Undefined
Description: SADEF-C+200X2.00; Material: STEEL/Steel_Undefined
Tekla Commun - Matériau: Steel_Undefined; Profil: SADEF-C+200X2.00
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 113.4 m2; Hauteur: 200 mm; Largeur: 100 mm
Pset_BeamCommon - LoadBearing: yes
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Phase | Classe | Nom | Poids (kg) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x POTEAU | +0.005 | +3.223 | P0(?) | 262 | 3 | POTEAU | 24.4 | 3.2 | 3217.6 | 3217.64 | 2.76717 | 0.00323051 | 25.3595
12 x ARBA | +2.605 | +3.845 | AB0(?) | 267 | 7 | ARBA | 51.9 | 6.9 | 6841.2 | 6841.19 | 5.88342 | 0.00686855 | 53.9182
12 x ARBA | +2.777 | +4.048 | AB0(?) | 267 | 7 | ARBA | 53.4 | 7.1 | 7047.1 | 7047.11 | 6.06051 | 0.0070753 | 55.5411
6 x POTEAU | -0.500 | +2.767 | P0(?) | 261 | 3 | POTEAU | 24.8 | 3.3 | 3267 | 3267 | 2.80962 | 0.00328007 | 25.7485
6 x POTEAU | -0.500 | +2.600 | P0(?) | 261 | 3 | POTEAU | 23.5 | 3.1 | 3100.3 | 3100.26 | 2.66622 | 0.00311266 | 24.4344
POTEAU | +0.005 | +2.100 | P0(?) | 262 | 3 | POTEAU | 15.8 | 2.1 | 2095 | 2095 | 1.8017 | 0.00210338 | 16.5115

# IfcColumn: SADEF-C+200X1.50 (2)
In: Undefined
Description: SADEF-C+200X1.50; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +1.159; Niveau haut: +2.100; Repère de pièce: LS0(?); Repère d'assemblage: LS0(?); Phase: 252; Classe: 14; Matériau: S235JR; Profil: SADEF-C+200X1.50; Nom: LISSE
Tekla Quantités - Poids: 5.3 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 151.5 m2; Surface nette: 1 m2; Hauteur: 200 mm; Largeur: 100 mm; Longueur: 941 mm
Pset_ColumnCommon - LoadBearing: yes; Reference: LS0(?)
BaseQuantities - Length: 941 mm; OuterSurfaceArea: 0.80926 m2; NetVolume: 0.000711396 m3; NetWeight: 5.58446 kg

# IfcColumn: SADEF-C+200X2.00 (17)
In: Undefined
Description: SADEF-C+200X2.00; Material: STEEL/Steel_Undefined
Tekla Commun - Repère de pièce: P0(?); Repère d'assemblage: P0(?); Classe: 3; Matériau: Steel_Undefined; Profil: SADEF-C+200X2.00; Nom: POTEAU
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 113.4 m2; Hauteur: 200 mm; Largeur: 100 mm
Pset_ColumnCommon - LoadBearing: yes; Reference: P0(?)
Name | Niveau bas | Niveau haut | Phase | Poids (kg) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x POTEAU | +0.005 | +3.223 | 262 | 24.4 | 3.2 | 3217.6 | 3217.64 | 2.76717 | 0.00323051 | 25.3595
6 x POTEAU | -0.500 | +2.767 | 261 | 24.8 | 3.3 | 3267 | 3267 | 2.80962 | 0.00328007 | 25.7485
6 x POTEAU | -0.500 | +2.600 | 261 | 23.5 | 3.1 | 3100.3 | 3100.26 | 2.66622 | 0.00311266 | 24.4344
POTEAU | +0.005 | +2.100 | 262 | 15.8 | 2.1 | 2095 | 2095 | 1.8017 | 0.00210338 | 16.5115

# IfcElementAssembly (492)
In: Undefined
Name | Poids Assemblage/Elément béton (kg) | Niveau Bas Assemblage/Elément béton | Niveau Haut Assemblage/Elément béton | Position maillage Assemblage/Elément béton | Repère Assemblage/Elément béton | Width (mm) | PredefinedType
Steel Assembly | 81.4 | -0.550 | -0.000 | 11/E | S0(?) | 130
Steel Assembly | 1619.2 | -1.000 | -0.000 | 11/D-E | S0(?) | 800
Steel Assembly | 81.4 | -0.550 | -0.000 | 9/E | S0(?) | 130
Steel Assembly | 1619.2 | -1.000 | -0.000 | 9/D-E | S0(?) | 800
Steel Assembly | 81.4 | -0.550 | -0.000 | 7/E | S0(?) | 130
Steel Assembly | 1619.2 | -1.000 | -0.000 | 7/D-E | S0(?) | 800
Steel Assembly | 81.4 | -0.550 | -0.000 | 5/E | S0(?) | 130
Steel Assembly | 1619.2 | -1.000 | -0.000 | 5/D-E | S0(?) | 800
Steel Assembly | 81.4 | -0.550 | -0.000 | 3/E | S0(?) | 130
Steel Assembly | 1619.2 | -1.000 | -0.000 | 3/D-E | S0(?) | 800
Steel Assembly | 81.4 | -0.550 | -0.000 | 1/E | S0(?) | 130
Steel Assembly | 1619.2 | -1.000 | -0.000 | 1/D-E | S0(?) | 800
Steel Assembly | 81.4 | -0.550 | -0.000 | 11/A | S0(?) | 130
Steel Assembly | 1619.2 | -1.000 | -0.000 | 11/A-B | S0(?) | 800
Steel Assembly | 81.4 | -0.550 | -0.000 | 9/A | S0(?) | 130
Steel Assembly | 1619.2 | -1.000 | -0.000 | 9/A-B | S0(?) | 800
Steel Assembly | 81.4 | -0.550 | -0.000 | 7/A | S0(?) | 130
Steel Assembly | 1619.2 | -1.000 | -0.000 | 7/A-B | S0(?) | 800
Steel Assembly | 81.4 | -0.550 | -0.000 | 5/A | S0(?) | 130
Steel Assembly | 1619.2 | -1.000 | -0.000 | 5/A-B | S0(?) | 800
Steel Assembly | 81.4 | -0.550 | -0.000 | 3/A | S0(?) | 130
Steel Assembly | 1619.2 | -1.000 | -0.000 | 3/A-B | S0(?) | 800
Steel Assembly | 81.4 | -0.550 | -0.000 | 1/A | S0(?) | 130
Steel Assembly | 1619.2 | -1.000 | -0.000 | 1/A-B | S0(?) | 800
Steel Assembly | 1.2 | +3.546 | +3.595 | 4/B-C | PL0(?) | 4 | RIGID_FRAME
Steel Assembly | 1.2 | +3.345 | +3.393 | 4/B-C | PL0(?) | 4 | RIGID_FRAME
Steel Assembly | 15.8 | +3.117 | +3.568 | 4-5/B-C | A0(?) | 100 | RIGID_FRAME
Steel Assembly | 15.8 | +3.372 | +3.823 | 3-4/B-C | A0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 2.9 | +3.598 | +3.828 | 3/C | A0(?) | 210 | RIGID_FRAME
Steel Assembly | 32.5 | +3.116 | +3.823 | 3-5/B-C | A0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 2.9 | +3.598 | +3.828 | 5/C | A0(?) | 210 | RIGID_FRAME
Steel Assembly | 1.2 | +3.032 | +3.081 | 4/A-B | PL0(?) | 4 | RIGID_FRAME
Steel Assembly | 1.2 | +2.831 | +2.879 | 4/A-B | PL0(?) | 4 | RIGID_FRAME
Steel Assembly | 5.7 | +3.088 | +3.341 | 5/B | A0(?) | 210 | RIGID_FRAME
Steel Assembly | 15.8 | +2.857 | +3.309 | 4-5/A-B | A0(?) | 100 | RIGID_FRAME
Steel Assembly | 15.8 | +2.602 | +3.054 | 3-4/A-B | A0(?) | 100 | RIGID_FRAME
Steel Assembly | 2.9 | +2.595 | +2.826 | 3/A | A0(?) | 210 | RIGID_FRAME
Steel Assembly | 5.7 | +3.088 | +3.341 | 3/B | A0(?) | 210 | RIGID_FRAME
Steel Assembly | 32.5 | +2.602 | +3.311 | 3-5/A-B | A0(?) | 100 | RIGID_FRAME
Steel Assembly | 2.9 | +2.595 | +2.826 | 5/A | A0(?) | 210 | RIGID_FRAME
Steel Assembly | 1.2 | +3.546 | +3.595 | 4/C-D | PL0(?) | 4 | RIGID_FRAME
Steel Assembly | 1.2 | +3.345 | +3.393 | 4/C-D | PL0(?) | 4 | RIGID_FRAME
Steel Assembly | 15.8 | +3.117 | +3.568 | 4-5/C-D | A0(?) | 100 | RIGID_FRAME
Steel Assembly | 15.8 | +3.372 | +3.823 | 3-4/C-D | A0(?) | 100 | RIGID_FRAME
Steel Assembly | 32.5 | +3.116 | +3.823 | 3-5/C-D | A0(?) | 100 | RIGID_FRAME
Steel Assembly | 15.8 | +2.602 | +3.054 | 3-4/D-E | A0(?) | 100 | RIGID_FRAME
Steel Assembly | 15.8 | +2.857 | +3.309 | 4-5/D-E | A0(?) | 100 | RIGID_FRAME
Steel Assembly | 32.5 | +2.602 | +3.311 | 3-5/D-E | A0(?) | 100 | RIGID_FRAME
Steel Assembly | 1.2 | +3.032 | +3.081 | 4/D-E | PL0(?) | 4 | RIGID_FRAME
Steel Assembly | 1.2 | +2.831 | +2.879 | 4/D-E | PL0(?) | 4 | RIGID_FRAME
Steel Assembly | 5.7 | +3.088 | +3.341 | 5/D | A0(?) | 210 | RIGID_FRAME
Steel Assembly | 5.7 | +3.088 | +3.341 | 3/D | A0(?) | 210 | RIGID_FRAME
Steel Assembly | 2.9 | +2.595 | +2.826 | 3/E | A0(?) | 210 | RIGID_FRAME
Steel Assembly | 1.1 | +2.808 | +2.993 | 5/A | AT0(?) | 151.013 | RIGID_FRAME
Steel Assembly | 1.1 | +2.808 | +2.993 | 3/A | AT0(?) | 151.013 | RIGID_FRAME
Steel Assembly | 2.9 | +2.595 | +2.826 | 5/E | A0(?) | 210 | RIGID_FRAME
Steel Assembly | 2.9 | +0.344 | +0.494 | 3/E | A0(?) | 210 | RIGID_FRAME
Steel Assembly | 2.9 | +2.404 | +2.554 | 5/E | A0(?) | 210 | RIGID_FRAME
Steel Assembly | 14 | +0.353 | +1.456 | 4-5/E | A0(?) | 100 | RIGID_FRAME
Steel Assembly | 14 | +1.464 | +2.567 | 3-4/E | A0(?) | 100 | RIGID_FRAME
Steel Assembly | 2.9 | +0.344 | +0.494 | 5/E | A0(?) | 210 | RIGID_FRAME
2 x Steel Assembly | 1.6 | +1.308 | +1.613 | 4/E | PL0(?) | 4 | RIGID_FRAME
Steel Assembly | 2.9 | +2.404 | +2.554 | 3/E | A0(?) | 210 | RIGID_FRAME
Steel Assembly | 29.3 | +0.353 | +2.567 | 3-5/E | A0(?) | 100 | RIGID_FRAME
Steel Assembly | 2.9 | +0.344 | +0.494 | 3/A | A0(?) | 210 | RIGID_FRAME
Steel Assembly | 29.3 | +0.353 | +2.567 | 3-5/A | A0(?) | 100 | RIGID_FRAME
Steel Assembly | 2.9 | +2.404 | +2.554 | 5/A | A0(?) | 210 | RIGID_FRAME
Steel Assembly | 14 | +1.464 | +2.567 | 3-4/A | A0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 1.6 | +1.308 | +1.613 | 4/A | PL0(?) | 4 | RIGID_FRAME
Steel Assembly | 14 | +0.353 | +1.456 | 4-5/A | A0(?) | 100 | RIGID_FRAME
Steel Assembly | 2.9 | +0.344 | +0.494 | 5/A | A0(?) | 210 | RIGID_FRAME
Steel Assembly | 24.8 | -0.500 | +2.767 | 11/E | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 23.5 | -0.500 | +2.600 | 11/E | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 24.8 | -0.500 | +2.767 | 9/E | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 23.5 | -0.500 | +2.600 | 9/E | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 24.8 | -0.500 | +2.767 | 7/E | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 23.5 | -0.500 | +2.600 | 7/E | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 24.8 | -0.500 | +2.767 | 5/E | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 23.5 | -0.500 | +2.600 | 5/E | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 24.8 | -0.500 | +2.767 | 3/E | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 23.5 | -0.500 | +2.600 | 3/E | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 24.8 | -0.500 | +2.767 | 1/E | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 23.5 | -0.500 | +2.600 | 1/E | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 24.8 | -0.500 | +2.767 | 11/A | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 23.5 | -0.500 | +2.600 | 11/A | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 24.8 | -0.500 | +2.767 | 9/A | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 23.5 | -0.500 | +2.600 | 9/A | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 24.8 | -0.500 | +2.767 | 7/A | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 23.5 | -0.500 | +2.600 | 7/A | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 24.8 | -0.500 | +2.767 | 5/A | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 23.5 | -0.500 | +2.600 | 5/A | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 24.8 | -0.500 | +2.767 | 3/A | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 23.5 | -0.500 | +2.600 | 3/A | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 24.8 | -0.500 | +2.767 | 1/A | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 23.5 | -0.500 | +2.600 | 1/A | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 2.9 | +2.404 | +2.554 | 3/A | A0(?) | 210 | RIGID_FRAME
Steel Assembly | 0.6 | +2.683 | +2.725 | 1/B-C | PL0(?) | 52 | RIGID_FRAME
Steel Assembly | 0.6 | +2.683 | +2.725 | 1/C-D | PL0(?) | 52 | RIGID_FRAME
Steel Assembly | 28.6 | +2.725 | +2.825 | 1/B-D | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +0.187 | +0.229 | 11/B-C | PL0(?) | 52 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +0.187 | +0.229 | 11/C-D | PL0(?) | 52 | RIGID_FRAME
Steel Assembly | 28.6 | +0.229 | +0.329 | 11/B-D | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +2.063 | +2.105 | 11/B-C | PL0(?) | 52 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +2.063 | +2.105 | 11/C-D | PL0(?) | 52 | RIGID_FRAME
Steel Assembly | 28.6 | +2.105 | +2.205 | 11/B-D | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 0.6 | +0.187 | +0.229 | 11/E | PL0(?) | 52 | RIGID_FRAME
Steel Assembly | 21.9 | +0.229 | +0.329 | 11/C-E | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 24.4 | +0.005 | +3.223 | 11/C-D | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 0.6 | +2.063 | +2.105 | 11/E | PL0(?) | 52 | RIGID_FRAME
Steel Assembly | 0.8 | +3.146 | +3.249 | 11/C-D | AT0(?) | 41.8379 | RIGID_FRAME
Steel Assembly | 1 | +0.000 | +0.102 | 11/C-D | PL0(?) | 72 | RIGID_FRAME
Steel Assembly | 21.9 | +2.105 | +2.205 | 11/C-E | LS0(?) | 100 | RIGID_FRAME
4 x Steel Assembly | 1.2 | +3.842 | +4.047 | 5/C | AT0(?) | 151.013 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +0.754 | +0.804 | 5/E | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +0.754 | +0.804 | 7/E | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +1.404 | +1.454 | 5/E | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +1.404 | +1.454 | 7/E | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +2.941 | +3.344 | 5/D-E | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +2.941 | +3.344 | 7/D-E | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 28.3 | +3.123 | +3.336 | 5-7/D-E | PA0(?) | 100 | RIGID_FRAME
Steel Assembly | 28.3 | +2.783 | +2.996 | 5-7/E | PA0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 28.3 | +3.827 | +4.040 | 5-7/C | PA0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +3.284 | +3.687 | 5/C-D | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +3.284 | +3.687 | 7/C-D | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 28.3 | +3.466 | +3.679 | 5-7/C-D | PA0(?) | 100 | RIGID_FRAME
4 x Steel Assembly | 1.2 | +3.842 | +4.047 | 7/C | AT0(?) | 151.013 | RIGID_FRAME
2 x Steel Assembly | 1.2 | +2.609 | +2.656 | 5/E | AT0(?) | 166.003 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +0.179 | +0.229 | 5/E | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +0.179 | +0.229 | 7/E | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 28.3 | +0.229 | +0.329 | 5-7/E | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +2.054 | +2.104 | 5/E | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 28.3 | +2.656 | +2.756 | 5-7/E | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +2.054 | +2.104 | 7/E | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 1 | +2.838 | +2.949 | 5/E | AT0(?) | 254.983 | RIGID_FRAME
Steel Assembly | 1.2 | +2.798 | +3.003 | 5/E | AT0(?) | 150.993 | RIGID_FRAME
2 x Steel Assembly | 1.2 | +2.798 | +3.003 | 7/E | AT0(?) | 151.013 | RIGID_FRAME
2 x Steel Assembly | 1.2 | +2.609 | +2.656 | 7/E | AT0(?) | 166.003 | RIGID_FRAME
Steel Assembly | 1.2 | +2.798 | +3.003 | 11/E | AT0(?) | 151.013 | RIGID_FRAME
Steel Assembly | 0.6 | +0.754 | +0.804 | 11/E | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +0.754 | +0.804 | 9/E | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 0.6 | +1.404 | +1.454 | 11/E | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +1.404 | +1.454 | 9/E | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 0.6 | +2.054 | +2.104 | 11/E | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 0.6 | +2.941 | +3.344 | 11/D-E | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +2.941 | +3.344 | 9/D-E | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 27.1 | +3.123 | +3.336 | 9-11/D-E | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 27.1 | +2.783 | +2.996 | 9-11/E | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 1.2 | +2.798 | +3.003 | 9/E | AT0(?) | 151.013 | RIGID_FRAME
2 x Steel Assembly | 1.2 | +3.842 | +4.047 | 11/C | AT0(?) | 151.013 | RIGID_FRAME
4 x Steel Assembly | 1.2 | +3.842 | +4.047 | 9/C | AT0(?) | 151.013 | RIGID_FRAME
2 x Steel Assembly | 27.1 | +3.827 | +4.040 | 9-11/C | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 0.6 | +3.284 | +3.687 | 11/C-D | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +3.284 | +3.687 | 9/C-D | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 27.1 | +3.466 | +3.679 | 9-11/C-D | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 1.2 | +2.609 | +2.656 | 11/E | AT0(?) | 166.003 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +2.054 | +2.104 | 9/E | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 27.1 | +2.656 | +2.756 | 9-11/E | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 0.6 | +0.179 | +0.229 | 11/E | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +0.179 | +0.229 | 9/E | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 27.1 | +0.229 | +0.329 | 9-11/E | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 51.9 | +2.605 | +3.845 | 11/C-E | AB0(?) | 100 | RIGID_FRAME
Steel Assembly | 53.4 | +2.777 | +4.048 | 11/C-E | AB0(?) | 100 | RIGID_FRAME
Steel Assembly | 6.9 | +2.454 | +3.036 | 11/E | G0(?) | 4 | RIGID_FRAME
2 x Steel Assembly | 0.8 | +0.000 | +0.054 | 11/E | CO0(?) | 54 | RIGID_FRAME
Steel Assembly | 1.1 | +2.808 | +2.993 | 5/E | AT0(?) | 151.013 | RIGID_FRAME
2 x Steel Assembly | 1 | +3.883 | +3.993 | 9/C | AT0(?) | 254.983 | RIGID_FRAME
Steel Assembly | 1 | +2.838 | +2.949 | 9/E | AT0(?) | 254.983 | RIGID_FRAME
2 x Steel Assembly | 1 | +3.883 | +3.993 | 3/C | AT0(?) | 254.983 | RIGID_FRAME
4 x Steel Assembly | 1.2 | +3.842 | +4.047 | 3/C | AT0(?) | 151.013 | RIGID_FRAME
Steel Assembly | 51.9 | +2.605 | +3.845 | 9/C-E | AB0(?) | 100 | RIGID_FRAME
Steel Assembly | 53.4 | +2.777 | +4.048 | 9/C-E | AB0(?) | 100 | RIGID_FRAME
Steel Assembly | 51.9 | +2.605 | +3.845 | 7/C-E | AB0(?) | 100 | RIGID_FRAME
Steel Assembly | 53.4 | +2.777 | +4.048 | 7/C-E | AB0(?) | 100 | RIGID_FRAME
Steel Assembly | 27.7 | +3.123 | +3.336 | 7-9/D-E | PA0(?) | 100 | RIGID_FRAME
Steel Assembly | 6.9 | +2.454 | +3.036 | 7/E | G0(?) | 4 | RIGID_FRAME
Steel Assembly | 27.7 | +2.783 | +2.996 | 7-9/E | PA0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 27.7 | +3.827 | +4.040 | 7-9/C | PA0(?) | 100 | RIGID_FRAME
Steel Assembly | 27.7 | +3.466 | +3.679 | 7-9/C-D | PA0(?) | 100 | RIGID_FRAME
Steel Assembly | 27.7 | +0.229 | +0.329 | 7-9/E | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 27.7 | +2.656 | +2.756 | 7-9/E | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.8 | +0.000 | +0.054 | 9/E | CO0(?) | 54 | RIGID_FRAME
2 x Steel Assembly | 0.8 | +0.000 | +0.054 | 7/E | CO0(?) | 54 | RIGID_FRAME
Steel Assembly | 1.2 | +2.798 | +3.003 | 9/E | AT0(?) | 150.993 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +0.754 | +0.804 | 3/E | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 0.6 | +0.754 | +0.804 | 1/E | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +1.404 | +1.454 | 3/E | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 0.6 | +1.404 | +1.454 | 1/E | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 24.4 | +0.005 | +3.223 | 1/C-D | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 51.9 | +2.605 | +3.845 | 1/C-E | AB0(?) | 100 | RIGID_FRAME
Steel Assembly | 53.4 | +2.777 | +4.048 | 1/C-E | AB0(?) | 100 | RIGID_FRAME
Steel Assembly | 51.9 | +2.605 | +3.845 | 3/C-E | AB0(?) | 100 | RIGID_FRAME
Steel Assembly | 53.4 | +2.777 | +4.048 | 3/C-E | AB0(?) | 100 | RIGID_FRAME
Steel Assembly | 51.9 | +2.605 | +3.845 | 5/C-E | AB0(?) | 100 | RIGID_FRAME
Steel Assembly | 53.4 | +2.777 | +4.048 | 5/C-E | AB0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +2.941 | +3.344 | 3/D-E | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 27.1 | +3.123 | +3.336 | 3-5/D-E | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 0.6 | +2.941 | +3.344 | 1/D-E | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 27.7 | +3.123 | +3.336 | 1-3/D-E | PA0(?) | 100 | RIGID_FRAME
Steel Assembly | 27.1 | +2.783 | +2.996 | 3-5/E | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 1.1 | +2.808 | +2.993 | 3/E | AT0(?) | 151.013 | RIGID_FRAME
2 x Steel Assembly | 27.1 | +3.827 | +4.040 | 3-5/C | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +3.284 | +3.687 | 3/C-D | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 27.1 | +3.466 | +3.679 | 3-5/C-D | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 1.2 | +2.609 | +2.656 | 3/E | AT0(?) | 166.003 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +2.054 | +2.104 | 3/E | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 27.1 | +2.656 | +2.756 | 3-5/E | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +0.179 | +0.229 | 3/E | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 27.1 | +0.229 | +0.329 | 3-5/E | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 6.9 | +2.454 | +3.036 | 1/E | G0(?) | 4 | RIGID_FRAME
Steel Assembly | 6.9 | +2.454 | +3.036 | 5/E | G0(?) | 4 | RIGID_FRAME
Steel Assembly | 6.9 | +2.454 | +3.036 | 3/E | G0(?) | 4 | RIGID_FRAME
2 x Steel Assembly | 0.8 | +0.000 | +0.054 | 5/E | CO0(?) | 54 | RIGID_FRAME
Steel Assembly | 27.7 | +2.783 | +2.996 | 1-3/E | PA0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 27.7 | +3.827 | +4.040 | 1-3/C | PA0(?) | 100 | RIGID_FRAME
Steel Assembly | 0.6 | +3.284 | +3.687 | 1/C-D | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 27.7 | +3.466 | +3.679 | 1-3/C-D | PA0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 1.2 | +3.842 | +4.047 | 1/C | AT0(?) | 151.013 | RIGID_FRAME
Steel Assembly | 1.2 | +2.609 | +2.656 | 1/E | AT0(?) | 166.003 | RIGID_FRAME
Steel Assembly | 0.6 | +0.179 | +0.229 | 1/E | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 27.7 | +0.229 | +0.329 | 1-3/E | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 27.7 | +2.656 | +2.756 | 1-3/E | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.8 | +0.000 | +0.054 | 3/E | CO0(?) | 54 | RIGID_FRAME
Steel Assembly | 0.6 | +2.054 | +2.104 | 1/E | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 21.9 | +2.105 | +2.205 | 1/C-E | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 16.2 | +0.229 | +0.329 | 1/D-E | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 16.2 | +1.054 | +1.154 | 1/D-E | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +1.154 | +1.206 | 1/D-E | PL0(?) | 52 | RIGID_FRAME
2 x Steel Assembly | 5.3 | +1.159 | +2.100 | 1/D-E | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +2.053 | +2.105 | 1/D-E | PL0(?) | 52 | RIGID_FRAME
Steel Assembly | 0.6 | +0.187 | +0.229 | 1/E | PL0(?) | 52 | RIGID_FRAME
Steel Assembly | 0.6 | +1.012 | +1.054 | 1/E | PL0(?) | 52 | RIGID_FRAME
Steel Assembly | 0.6 | +2.063 | +2.105 | 1/E | PL0(?) | 52 | RIGID_FRAME
Steel Assembly | 15.8 | +0.005 | +2.100 | 1/D | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 0.6 | +2.063 | +2.105 | 1/C-D | PL0(?) | 52 | RIGID_FRAME
Steel Assembly | 0.8 | +3.146 | +3.249 | 1/C-D | AT0(?) | 41.8379 | RIGID_FRAME
Steel Assembly | 1 | +0.000 | +0.102 | 1/C-D | PL0(?) | 72 | RIGID_FRAME
Steel Assembly | 0.6 | +1.012 | +1.054 | 1/D | PL0(?) | 52 | RIGID_FRAME
Steel Assembly | 0.6 | +0.187 | +0.229 | 1/D | PL0(?) | 52 | RIGID_FRAME
Steel Assembly | 0.6 | +2.063 | +2.105 | 1/D | PL0(?) | 52 | RIGID_FRAME
Steel Assembly | 0.8 | +0.000 | +0.102 | 1/D | PL0(?) | 52 | RIGID_FRAME
2 x Steel Assembly | 0.8 | +0.000 | +0.054 | 1/E | CO0(?) | 54 | RIGID_FRAME
Steel Assembly | 1 | +2.838 | +2.949 | 3/E | AT0(?) | 254.983 | RIGID_FRAME
Steel Assembly | 1.2 | +2.798 | +3.003 | 3/E | AT0(?) | 150.993 | RIGID_FRAME
Steel Assembly | 1.2 | +2.798 | +3.003 | 1/E | AT0(?) | 151.013 | RIGID_FRAME
Steel Assembly | 0.6 | +2.104 | +2.204 | 11/E | PLA0(?) | 2 | RIGID_FRAME
Steel Assembly | 0.6 | +0.229 | +0.329 | 11/E | PLA0(?) | 2 | RIGID_FRAME
Steel Assembly | 0.6 | +2.104 | +2.204 | 1/E | PLA0(?) | 2 | RIGID_FRAME
Steel Assembly | 0.6 | +0.229 | +0.329 | 1/E | PLA0(?) | 2 | RIGID_FRAME
Steel Assembly | 0.6 | +0.187 | +0.229 | 11/A | PL0(?) | 52 | RIGID_FRAME
Steel Assembly | 21.9 | +0.229 | +0.329 | 11/A-C | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 24.4 | +0.005 | +3.223 | 11/B-C | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 0.6 | +2.063 | +2.105 | 11/A | PL0(?) | 52 | RIGID_FRAME
Steel Assembly | 0.8 | +3.146 | +3.249 | 11/B-C | AT0(?) | 41.8379 | RIGID_FRAME
Steel Assembly | 1 | +0.000 | +0.102 | 11/B-C | PL0(?) | 72 | RIGID_FRAME
Steel Assembly | 21.9 | +2.105 | +2.205 | 11/A-C | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 0.6 | +2.104 | +2.204 | 11/A | PLA0(?) | 2 | RIGID_FRAME
Steel Assembly | 0.6 | +0.229 | +0.329 | 11/A | PLA0(?) | 2 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +0.754 | +0.804 | 5/A | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +0.754 | +0.804 | 7/A | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +1.404 | +1.454 | 5/A | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +1.404 | +1.454 | 7/A | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +2.941 | +3.344 | 5/A-B | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +2.941 | +3.344 | 7/A-B | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 28.3 | +3.123 | +3.336 | 5-7/A-B | PA0(?) | 100 | RIGID_FRAME
Steel Assembly | 28.3 | +2.783 | +2.996 | 5-7/A | PA0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +3.284 | +3.687 | 5/B-C | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +3.284 | +3.687 | 7/B-C | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 28.3 | +3.466 | +3.679 | 5-7/B-C | PA0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 1.2 | +2.609 | +2.656 | 5/A | AT0(?) | 166.003 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +0.179 | +0.229 | 5/A | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +0.179 | +0.229 | 7/A | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 28.3 | +0.229 | +0.329 | 5-7/A | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +2.054 | +2.104 | 5/A | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 28.3 | +2.656 | +2.756 | 5-7/A | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +2.054 | +2.104 | 7/A | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 1 | +2.838 | +2.949 | 5/A | AT0(?) | 254.983 | RIGID_FRAME
Steel Assembly | 1.2 | +2.798 | +3.003 | 5/A | AT0(?) | 150.993 | RIGID_FRAME
2 x Steel Assembly | 1.2 | +2.798 | +3.003 | 7/A | AT0(?) | 151.013 | RIGID_FRAME
2 x Steel Assembly | 1.2 | +2.609 | +2.656 | 7/A | AT0(?) | 166.003 | RIGID_FRAME
Steel Assembly | 1.2 | +2.798 | +3.003 | 11/A | AT0(?) | 151.013 | RIGID_FRAME
Steel Assembly | 0.6 | +0.754 | +0.804 | 11/A | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +0.754 | +0.804 | 9/A | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 0.6 | +1.404 | +1.454 | 11/A | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +1.404 | +1.454 | 9/A | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 0.6 | +2.054 | +2.104 | 11/A | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 0.6 | +2.941 | +3.344 | 11/A-B | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +2.941 | +3.344 | 9/A-B | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 27.1 | +3.123 | +3.336 | 9-11/A-B | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 27.1 | +2.783 | +2.996 | 9-11/A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 1.2 | +2.798 | +3.003 | 9/A | AT0(?) | 151.013 | RIGID_FRAME
Steel Assembly | 0.6 | +3.284 | +3.687 | 11/B-C | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +3.284 | +3.687 | 9/B-C | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 27.1 | +3.466 | +3.679 | 9-11/B-C | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 1.2 | +2.609 | +2.656 | 11/A | AT0(?) | 166.003 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +2.054 | +2.104 | 9/A | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 27.1 | +2.656 | +2.756 | 9-11/A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 0.6 | +0.179 | +0.229 | 11/A | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +0.179 | +0.229 | 9/A | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 27.1 | +0.229 | +0.329 | 9-11/A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 51.9 | +2.605 | +3.845 | 11/A-C | AB0(?) | 100 | RIGID_FRAME
Steel Assembly | 53.4 | +2.777 | +4.048 | 11/A-C | AB0(?) | 100 | RIGID_FRAME
Steel Assembly | 6.9 | +2.454 | +3.036 | 11/A | G0(?) | 4 | RIGID_FRAME
Steel Assembly | 8.3 | +3.603 | +4.053 | 11/C | G0(?) | 4 | RIGID_FRAME
2 x Steel Assembly | 0.8 | +0.000 | +0.054 | 11/A | CO0(?) | 54 | RIGID_FRAME
Steel Assembly | 1 | +2.838 | +2.949 | 9/A | AT0(?) | 254.983 | RIGID_FRAME
Steel Assembly | 51.9 | +2.605 | +3.845 | 9/A-C | AB0(?) | 100 | RIGID_FRAME
Steel Assembly | 53.4 | +2.777 | +4.048 | 9/A-C | AB0(?) | 100 | RIGID_FRAME
Steel Assembly | 51.9 | +2.605 | +3.845 | 7/A-C | AB0(?) | 100 | RIGID_FRAME
Steel Assembly | 53.4 | +2.777 | +4.048 | 7/A-C | AB0(?) | 100 | RIGID_FRAME
Steel Assembly | 27.7 | +3.123 | +3.336 | 7-9/A-B | PA0(?) | 100 | RIGID_FRAME
Steel Assembly | 6.9 | +2.454 | +3.036 | 7/A | G0(?) | 4 | RIGID_FRAME
Steel Assembly | 8.3 | +3.603 | +4.053 | 7/C | G0(?) | 4 | RIGID_FRAME
Steel Assembly | 8.3 | +3.603 | +4.053 | 9/C | G0(?) | 4 | RIGID_FRAME
Steel Assembly | 27.7 | +2.783 | +2.996 | 7-9/A | PA0(?) | 100 | RIGID_FRAME
Steel Assembly | 27.7 | +3.466 | +3.679 | 7-9/B-C | PA0(?) | 100 | RIGID_FRAME
Steel Assembly | 27.7 | +0.229 | +0.329 | 7-9/A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 27.7 | +2.656 | +2.756 | 7-9/A | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.8 | +0.000 | +0.054 | 9/A | CO0(?) | 54 | RIGID_FRAME
2 x Steel Assembly | 0.8 | +0.000 | +0.054 | 7/A | CO0(?) | 54 | RIGID_FRAME
Steel Assembly | 1.2 | +2.798 | +3.003 | 9/A | AT0(?) | 150.993 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +0.754 | +0.804 | 3/A | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 0.6 | +0.754 | +0.804 | 1/A | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +1.404 | +1.454 | 3/A | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 0.6 | +1.404 | +1.454 | 1/A | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 24.4 | +0.005 | +3.223 | 1/B-C | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 51.9 | +2.605 | +3.845 | 1/A-C | AB0(?) | 100 | RIGID_FRAME
Steel Assembly | 53.4 | +2.777 | +4.048 | 1/A-C | AB0(?) | 100 | RIGID_FRAME
Steel Assembly | 51.9 | +2.605 | +3.845 | 3/A-C | AB0(?) | 100 | RIGID_FRAME
Steel Assembly | 53.4 | +2.777 | +4.048 | 3/A-C | AB0(?) | 100 | RIGID_FRAME
Steel Assembly | 51.9 | +2.605 | +3.845 | 5/A-C | AB0(?) | 100 | RIGID_FRAME
Steel Assembly | 53.4 | +2.777 | +4.048 | 5/A-C | AB0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +2.941 | +3.344 | 3/A-B | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 27.1 | +3.123 | +3.336 | 3-5/A-B | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 0.6 | +2.941 | +3.344 | 1/A-B | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 27.7 | +3.123 | +3.336 | 1-3/A-B | PA0(?) | 100 | RIGID_FRAME
Steel Assembly | 1.2 | +12.793 | +12.998 | 5/E> | AT0(?) | 151.013 | RIGID_FRAME
Steel Assembly | 27.1 | +2.783 | +2.996 | 3-5/A | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +3.284 | +3.687 | 3/B-C | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 27.1 | +3.466 | +3.679 | 3-5/B-C | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 1.2 | +2.609 | +2.656 | 3/A | AT0(?) | 166.003 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +2.054 | +2.104 | 3/A | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 27.1 | +2.656 | +2.756 | 3-5/A | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +0.179 | +0.229 | 3/A | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 27.1 | +0.229 | +0.329 | 3-5/A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 6.9 | +2.454 | +3.036 | 1/A | G0(?) | 4 | RIGID_FRAME
Steel Assembly | 6.9 | +2.454 | +3.036 | 5/A | G0(?) | 4 | RIGID_FRAME
Steel Assembly | 6.9 | +2.454 | +3.036 | 3/A | G0(?) | 4 | RIGID_FRAME
Steel Assembly | 8.3 | +3.603 | +4.053 | 1/C | G0(?) | 4 | RIGID_FRAME
Steel Assembly | 8.3 | +3.603 | +4.053 | 3/C | G0(?) | 4 | RIGID_FRAME
Steel Assembly | 8.3 | +3.603 | +4.053 | 5/C | G0(?) | 4 | RIGID_FRAME
2 x Steel Assembly | 0.8 | +0.000 | +0.054 | 5/A | CO0(?) | 54 | RIGID_FRAME
Steel Assembly | 27.7 | +2.783 | +2.996 | 1-3/A | PA0(?) | 100 | RIGID_FRAME
Steel Assembly | 0.6 | +3.284 | +3.687 | 1/B-C | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 27.7 | +3.466 | +3.679 | 1-3/B-C | PA0(?) | 100 | RIGID_FRAME
Steel Assembly | 1.2 | +2.609 | +2.656 | 1/A | AT0(?) | 166.003 | RIGID_FRAME
Steel Assembly | 0.6 | +0.179 | +0.229 | 1/A | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 27.7 | +0.229 | +0.329 | 1-3/A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 27.7 | +2.656 | +2.756 | 1-3/A | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.8 | +0.000 | +0.054 | 3/A | CO0(?) | 54 | RIGID_FRAME
Steel Assembly | 0.6 | +2.054 | +2.104 | 1/A | CO0(?) | 50.0001 | RIGID_FRAME
Steel Assembly | 21.9 | +2.105 | +2.205 | 1/A-C | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 16.2 | +0.229 | +0.329 | 1/A-B | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 16.2 | +1.054 | +1.154 | 1/A-B | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +1.154 | +1.206 | 1/A-B | PL0(?) | 52 | RIGID_FRAME
2 x Steel Assembly | 5.3 | +1.159 | +2.100 | 1/A-B | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +2.053 | +2.105 | 1/A-B | PL0(?) | 52 | RIGID_FRAME
Steel Assembly | 0.6 | +0.187 | +0.229 | 1/A | PL0(?) | 52 | RIGID_FRAME
Steel Assembly | 0.6 | +1.012 | +1.054 | 1/A | PL0(?) | 52 | RIGID_FRAME
Steel Assembly | 0.6 | +2.063 | +2.105 | 1/A | PL0(?) | 52 | RIGID_FRAME
Steel Assembly | 15.8 | +0.005 | +2.100 | 1/B | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 0.6 | +2.063 | +2.105 | 1/B-C | PL0(?) | 52 | RIGID_FRAME
Steel Assembly | 0.8 | +3.146 | +3.249 | 1/B-C | AT0(?) | 41.8379 | RIGID_FRAME
Steel Assembly | 1 | +0.000 | +0.102 | 1/B-C | PL0(?) | 72 | RIGID_FRAME
Steel Assembly | 0.6 | +1.012 | +1.054 | 1/B | PL0(?) | 52 | RIGID_FRAME
Steel Assembly | 0.6 | +0.187 | +0.229 | 1/B | PL0(?) | 52 | RIGID_FRAME
Steel Assembly | 0.6 | +2.063 | +2.105 | 1/B | PL0(?) | 52 | RIGID_FRAME
Steel Assembly | 0.8 | +0.000 | +0.102 | 1/B | PL0(?) | 52 | RIGID_FRAME
2 x Steel Assembly | 0.8 | +0.000 | +0.054 | 1/A | CO0(?) | 54 | RIGID_FRAME
Steel Assembly | 1 | +2.838 | +2.949 | 3/A | AT0(?) | 254.983 | RIGID_FRAME
Steel Assembly | 1.2 | +2.798 | +3.003 | 3/A | AT0(?) | 150.993 | RIGID_FRAME
Steel Assembly | 1.2 | +2.798 | +3.003 | 1/A | AT0(?) | 151.013 | RIGID_FRAME
Steel Assembly | 0.6 | +2.104 | +2.204 | 1/A | PLA0(?) | 2 | RIGID_FRAME
Steel Assembly | 0.6 | +0.229 | +0.329 | 1/A | PLA0(?) | 2 | RIGID_FRAME
Steel Assembly | 0.8 | +0.000 | +0.054 | 1/<A | CO0(?) | 54 | RIGID_FRAME
Steel Assembly | 0.8 | +0.000 | +0.054 | 9/<A | CO0(?) | 54 | RIGID_FRAME

# IfcFooting: 450*130 (12)
In: Undefined
Description: 450*130; Material: MISCELLANEOUS/VERRE
Tekla Commun - Niveau bas: -0.550; Niveau haut: -0.000; Repère de pièce: S0(?); Repère d'assemblage: S0(?); Phase: 266; Classe: 8; Matériau: VERRE; Profil: 450*130; Nom: SEMELLE
Tekla Quantités - Poids: 81.4 kg; Volume: 0 m3; Surface supérieure totale: 0.1 m2; Surface par tonne: 9.3 m2; Surface nette: 0.8 m2; Hauteur: 450 mm; Largeur: 130 mm; Longueur: 550 mm
BaseQuantities - Length: 550 mm; OuterSurfaceArea: 0.755 m2; GrossSurfaceArea: 0.755 m2; CrossSectionArea: 0.0585 m2; NetVolume: 0.032175 m3; GrossVolume: 0.032175 m3; NetWeight: 81.4027 kg; GrossWeight: 81.4027 kg; Width: 130 mm; Height: 450 mm

# IfcFooting: 800*800 (12)
In: Undefined
Description: 800*800; Material: MISCELLANEOUS/VERRE
Tekla Commun - Niveau bas: -1.000; Niveau haut: -0.000; Repère de pièce: S0(?); Repère d'assemblage: S0(?); Phase: 266; Classe: 8; Matériau: VERRE; Profil: 800*800; Nom: SEMELLE
Tekla Quantités - Poids: 1619.2 kg; Volume: 0.6 m3; Surface supérieure totale: 0.6 m2; Surface par tonne: 2.8 m2; Surface nette: 4.5 m2; Hauteur: 800 mm; Largeur: 800 mm; Longueur: 1000 mm
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 4.48 m2; GrossSurfaceArea: 4.48 m2; CrossSectionArea: 0.64 m2; NetVolume: 0.64 m3; GrossVolume: 0.64 m3; NetWeight: 1619.2 kg; GrossWeight: 1619.2 kg; Width: 800 mm; Height: 800 mm

# IfcMechanicalFastener: Bolt assembly (7190)
In: Undefined
Material: 8.8
Tekla Boulons - Quantité de rondelle: 0; Type rondelle: PLA-8.8; Type écrou: E-8.8; Trou oblong Y: 0 mm; Trou oblong X: 0 mm; Lieu Boulonnage: Montage; Standard: 8.8
Name | NominalDiameter (mm) = Diamètre rondelle (mm) = Diamètre (mm) | NominalLength (mm) | Nom rondelle | Quantité d'écrou | Nom écrou | Diamètre du trou (mm) | Quantité | Longueur (mm) | Nom
156 x Bolt assembly | 12 | 25 | RONDELLE-M12-PLA-8.8 | 1 | ECROU-M12-E-8.8 | 14 | 1 | 25 | M12*25
244 x Bolt assembly | 12 | 1.5 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 1 | 1.5 | M12*25
185 x Bolt assembly | 12 | 25 | RONDELLE-M12-PLA-8.8 | 4 | ECROU-M12-E-8.8 | 14 | 4 | 25 | M12*25
867 x Bolt assembly | 12 | 25 | RONDELLE-M12-PLA-8.8 | 2 | ECROU-M12-E-8.8 | 14 | 2 | 25 | M12*25
5036 x Bolt assembly | 12 | 2 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 2 | 2 | M12*25
13 x Bolt assembly | 12 | 4.0002 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 2 | 4 | M12*25
383 x Bolt assembly | 12 | 1.5 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 2 | 1.5 | M12*25
188 x Bolt assembly | 12 | 2 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 1 | 2 | M12*25
6 x Bolt assembly | 24 | 4 | RONDELLE-M24-PLA-8.8 | 0 | ECROU-M24-E-8.8 | 26 | 1 | 4 | M24*50
6 x Bolt assembly | 12 | 4 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 4 | 4 | M12*25
106 x Bolt assembly | 12 | 4 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 2 | 4 | M12*25

# IfcMember: SADEF-C+200X1.50 (6)
In: Undefined
Description: SADEF-C+200X1.50; Material: STEEL/Steel_Undefined
Tekla Commun - Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 6; Matériau: Steel_Undefined; Profil: SADEF-C+200X1.50; Nom: ARBA
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 151.5 m2; Hauteur: 200 mm; Largeur: 100 mm
Pset_MemberCommon - LoadBearing: yes; Reference: A0(?)
BaseQuantities - CrossSectionArea: 0.000723 m2
Name | Niveau bas | Niveau haut | Poids (kg) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
2 x ARBA | +0.353 | +1.456 | 14 | 2.5 | 2461.4 | 2461.44 | 2.11684 | 0.00186085 | 0.00177962 | 14.6076 | 13.97
2 x ARBA | +1.464 | +2.567 | 14 | 2.5 | 2461.4 | 2461.44 | 2.11684 | 0.00186085 | 0.00177962 | 14.6076 | 13.97
2 x ARBA | +0.353 | +2.567 | 29.3 | 5.2 | 5164.9 | 5164.94 | 4.44185 | 0.0039047 | 0.00373425 | 30.6519 | 29.3139

# IfcPlate: PL2*100 (8)
In: Undefined
Description: PL2*100; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: PLA0(?); Repère d'assemblage: PLA0(?); Phase: 262; Classe: 99; Matériau: S235JR; Profil: PL2*100; Nom: PLAT
Tekla Quantités - Poids: 0.6 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 130.6 m2; Surface nette: 0.1 m2; Hauteur: 100 mm; Largeur: 2 mm; Longueur: 400 mm
Pset_PlateCommon - LoadBearing: yes; Reference: PLA0(?)
BaseQuantities - Width: 100 mm; NetArea: 0.082 m2; GrossArea: 0.04 m2; CrossSectionArea: 0.000004 m2; NetVolume: 0.00008 m3; GrossVolume: 0.00008 m3
Name | Niveau bas | Niveau haut
4 x PLAT | +2.104 | +2.204
4 x PLAT | +0.229 | +0.329

# IfcPlate: PL4*100 (12)
In: Undefined
Description: PL4*100; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: PL0(?); Repère d'assemblage: PL0(?); Classe: 99; Matériau: S235JR; Profil: PL4*100; Nom: PLAT
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 100 mm; Largeur: 4 mm
Pset_PlateCommon - LoadBearing: yes; Reference: PL0(?)
BaseQuantities - Width: 100 mm; CrossSectionArea: 0.000016 m2
Name | Niveau bas | Niveau haut | Phase | Poids (kg) | Surface par tonne (m2) | Longueur (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x PLAT | +3.546 | +3.595 | 264 | 1.2 | 66.9 | 370 | 0.0777704 | 0.037005 | 0.00014802
2 x PLAT | +3.345 | +3.393 | 264 | 1.2 | 66.9 | 370 | 0.0777704 | 0.037005 | 0.00014802
2 x PLAT | +3.032 | +3.081 | 264 | 1.2 | 66.9 | 370 | 0.0777704 | 0.037005 | 0.00014802
2 x PLAT | +2.831 | +2.879 | 264 | 1.2 | 66.9 | 370 | 0.0777704 | 0.037005 | 0.00014802
4 x PLAT | +1.308 | +1.613 | 265 | 1.6 | 66.7 | 520 | 0.10897 | 0.052005 | 0.00020802

# IfcPlate: PL4*400 (10)
In: Undefined
Description: PL4*400; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +2.454; Niveau haut: +3.036; Repère de pièce: G0(?); Repère d'assemblage: G0(?); Phase: 267; Classe: 99; Matériau: S235JR; Profil: PL4*400; Nom: GOUSSET
Tekla Quantités - Poids: 6.9 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 64.8 m2; Surface nette: 0.4 m2; Hauteur: 400.2 mm; Largeur: 4 mm; Longueur: 582 mm
Pset_PlateCommon - LoadBearing: yes; Reference: G0(?)
BaseQuantities - Width: 400.158 mm; NetArea: 0.448656 m2; GrossArea: 0.232894 m2; CrossSectionArea: 0.000016 m2; NetVolume: 0.000882055 m3; GrossVolume: 0.000882055 m3

# IfcPlate: PL4*450 (6)
In: Undefined
Description: PL4*450; Material: STEEL/S235JR
Pset_PlateCommon - LoadBearing: yes; Reference: G0(?)
Tekla Commun - Niveau bas: +3.603; Niveau haut: +4.053; Repère de pièce: G0(?); Repère d'assemblage: G0(?); Phase: 267; Classe: 99; Matériau: S235JR; Profil: PL4*450; Nom: GOUSSET
Tekla Quantités - Poids: 8.3 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 64.8 m2; Surface nette: 0.4 m2; Hauteur: 450.1 mm; Largeur: 4 mm; Longueur: 682.4 mm
BaseQuantities - Width: 450.149 mm; NetArea: 0.537583 m2; GrossArea: 0.307168 m2; CrossSectionArea: 0.000016 m2; NetVolume: 0.00105873 m3; GrossVolume: 0.00105873 m3
